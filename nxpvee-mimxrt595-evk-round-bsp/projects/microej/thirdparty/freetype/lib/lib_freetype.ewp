# IAR project lib_freetype.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT595S_M33 NXP MIMXRT595S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: FT_CONFIG_MODULES_H=<freetype/config/ftmodule.h>; FT2_BUILD_LIBRARY; CPU_MIMXRT595SFFOB_cm33; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS; PRINTF_ADVANCED_ENABLE=1; PRINTF_FLOAT_ENABLE=1
  ICCARM.CCIncludePath2: ../../../platform/inc; ../../../board/inc; ../../../freertos/inc; ../../../main/inc; ../../../trace/inc; ../../../ui/inc; ../../../util/inc; ../../../vg/inc; ../../../thirdparty/freetype/inc; ../../../thirdparty/systemview/inc; ../../../thirdparty/systemview-freertos/inc; ../../../../../sdk/CMSIS/Include; ../../../../../sdk/devices; ../../../../../sdk/rtos/freertos/lib/include; ../../../../../sdk/rtos/freertos/lib/include/private; ../../../../../sdk/components/ft3267; ../../../../../sdk/components/video; ../../../../../sdk/components/video/display; ../../../../../sdk/components/video/display/dbi; ../../../../../sdk/components/video/display/dbi/flexio; ../../../../../sdk/components/video/display/dc/ssd1963; ../../../../../sdk/components/video/display/dc/lcdif; ../../../../../sdk/components/video/display/rm68191; ../../../../../sdk/components/video/display/mipi_dsi_cmd; ../../../../../sdk/components/video/display/rm68200; ../../../../../sdk/components/video/display/rm67162; ../../../../../sdk/components/video/display/dc/dsi_cmd; ../../../../../sdk/components/video/display/fbdev; ../../../../../sdk/components/uart; ../../../../../sdk/components/serial_manager; ../../../../../sdk/components/lists; ../../../../../sdk/components/video/display/dc; ../../../../../sdk/devices/MIMXRT595S; ../../../../../sdk/devices/MIMXRT595S/drivers; ../../../../../sdk/devices/MIMXRT595S/utilities/debug_console; ../../../../../sdk/devices/MIMXRT595S/utilities/str; ../../../../../sdk/devices/MIMXRT595S/xip; ../../../../../sdk/middleware/vglite/inc; ../../../../../sdk/middleware/vglite/VGLiteKernel; ../../../../../sdk/middleware/vglite/VGLiteKernel/rtos; ../../../../../sdk/middleware/vglite/VGLite/rtos; ../../../../../sdk/rtos/freertos/freertos_kernel/include_; ../../../../../sdk/rtos/freertos/freertos_kernel/portable/IAR/ARM_CM33_NTZ/non_secure_; ../../../../../sdk/rtos/amazon-freertos/freertos_kernel/include; ../../../../../sdk/rtos/amazon-freertos/freertos_kernel/portable/IAR/ARM_CM33_NTZ/non_secure; ../../../osal/inc; ../../../platform/inc; ../../../vglite_support; ../../../vglite_window; ../../../thirdparty/harfbuzz/inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lib_freetype.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group (top)
    ../src/wrappers/: ft_base_wrapper.c ft_bitmap_wrapper.c ft_otf_wrapper.c ft_ttf_wrapper.c ft_vector_wrapper.c
